# Keil uVision project nv32f100_codebase.uvprojx, settings and files
target NV32-Flash (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: nv32f100_codebase
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KEIL NV32 CMSIS
  c include: .\src;.\include;.\common;.\cpu;.\cpu\headers;.\platforms;.\drivers\sim;.\drivers\uart;.\drivers\gpio;.\drivers\wdog;.\drivers\ics;.\drivers\etm;.\drivers\rtc;.\drivers\bos;.\drivers\acmp;.\drivers\adc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
  memory RVCT10: RAM 0x1ffff800 size 0x800
  group common
    ./common/: alloc.c assert.c io.c memtest.c queue.c stdlib.c
  group cpu
    ./cpu/: arm_cm0.c start.c sysinit.c systick.c vectors.c startup_NV32.s
  group driver
    ./drivers/acmp/: acmp.c
    ./drivers/adc/: adc.c
    ./drivers/crc/: crc.c
    ./drivers/gpio/: gpio.c
    ./drivers/ics/: ics.c
    ./drivers/iic/: i2c.c
    ./drivers/kbi/: kbi.c
    ./drivers/nvm/: flash.c
    ./drivers/pit/: pit.c
    ./drivers/PMC/: pmc.c
    ./drivers/rtc/: rtc.c
    ./drivers/sim/: sim.c
    ./drivers/spi/: spi.c
    ./drivers/uart/: uart.c
    ./drivers/wdog/: wdog.c
    ./drivers/etm/: etm.c
    ./drivers/delay/: delay.c
  group src
    ./src/: main.c
